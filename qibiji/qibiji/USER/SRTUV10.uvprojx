# Keil uVision project SRTUV10.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QIBIJI +hex
  AfterMake: .\HEXBIN.bat $K !L @L $L
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\USART;..\HARDWARE\DC_MOTOR;..\HARDWARE\Lcd12864;..\HARDWARE\CRC16;..\HARDWARE\WDG;..\HARDWARE\ADC;..\HARDWARE\24CXX;..\HARDWARE\MODBUS;..\HARDWARE\DS1302;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\4G;..\HARDWARE\SWITCH;..\HARDWARE\MQTT;..\HARDWARE\GPRS;..\HARDWARE\cJSON;..\HARDWARE\MALLOC;..\HARDWARE\REG;..\HARDWARE\485;..\HARDWARE\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x800e000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c main.h
  group HARDWARE
    ../HARDWARE/GPRS/: uart_queue.c gprs_AT.c gprs_JSON.c event_pub.c property_report.c net_liveness.c
    ../HARDWARE/4G/: 4G.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/cJSON/: cJSON.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/USART/: usart1.c usart2.c usart4.c uart3_at_sequence.c usart3.c sbf20.c sbf20_app.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/REG/: reg.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DC_MOTOR/: dc_motor.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SWITCH/: switch.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/Lcd12864/: Lcd12864.C Dispaly.c DispalyPara.c
    ../HARDWARE/485/: 485.c
    ../HARDWARE/CRC16/: crc16.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c
