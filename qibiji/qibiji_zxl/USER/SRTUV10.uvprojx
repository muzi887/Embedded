# Keil uVision project SRTUV10.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QIBIJI +hex
  AfterMake: .\HEXBIN.bat $K !L @L $L
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\CORE;..\HARDWARE\DEBUG_UART;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\LCD12864;..\HARDWARE\ADC;..\HARDWARE\DCMOTOR;..\HARDWARE\GATEIO;..\HARDWARE\GPRS;..\HARDWARE\DS1302;..\HARDWARE\EEPROM;..\HARDWARE\IIC;..\HARDWARE\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c main.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/DEBUG_UART/: debug_uart.c debug_uart.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/LCD12864/: lcd12864.c lcd12864.h lcd_pages.c lcd_pages.h lcd_backlight.c lcd_backlight.h
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/DCMOTOR/: dcmotor.c dcmotor.h dcmotor_param.c dcmotor_param.h
    ../HARDWARE/GATEIO/: gate_io.c gate_io.h
    ../HARDWARE/GPRS/: gprs_4g.c gprs_4g.h gprs_at.c gprs_at.h gprs_config.h gprs_port.c gprs_port.h uart_queue.c uart_queue.h gprs.c gprs_json.c gprs_json.h gprs.h cJSON.c cJSON.h malloc.c mymalloc.h event_pub.h net_liveness.h property_report.h property_report.c gprs_rtc.c gprs_rtc.h net_liveness.c gprs_config_store.c gprs_config_store.h
    ../HARDWARE/DS1302/: ds1302.c ds1302.h
    ../HARDWARE/IIC/: myiic.c myiic.h
    ../HARDWARE/EEPROM/: eeprom_drv.c eeprom_drv.h
    ../HARDWARE/WDG/: wdg.c wdg.h
