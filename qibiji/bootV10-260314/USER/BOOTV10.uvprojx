# Keil uVision project BOOTV10.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: .\HEXBIN.bat $K !L @L $L
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\USART;..\HARDWARE\DC_MOTOR;..\HARDWARE\WDG;..\HARDWARE\24CXX;..\HARDWARE\DS1302;..\HARDWARE\IIC;..\HARDWARE\4G;..\HARDWARE\REG;..\HARDWARE\BOOT;..\HARDWARE\STMFLASH;..\HARDWARE\Lcd12864;..\HARDWARE\GPRS;..\HARDWARE\cJSON;..\HARDWARE\MALLOC;..\HARDWARE\CRC16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/USART/: usart1.c usart2.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/REG/: reg.c
    ../HARDWARE/DC_MOTOR/: dc_motor.c
    ../HARDWARE/4G/: 4G.c
    ../HARDWARE/BOOT/: boot.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/Lcd12864/: Dispaly.c DispalyPara.c Lcd12864.C ProgressBar.c
    ../HARDWARE/GPRS/: gprs_rx.c gprs_tx.c
    ../HARDWARE/cJSON/: cJSON.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/CRC16/: crc16.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c
