# Keil uVision project tikong.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tikong
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Start;..\Library\inc;..\System\delay;..\System\sys;..\Hardware\Serial;..\Hardware\Storage;..\Hardware\Time;..\Hardware\Board;..\Hardware\Modem;..\Middlewares;..\App\Pass;..\App\Cloud;..\App\Store;..\App\Link;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ../Start/: startup_stm32f40_41xxx.s system_stm32f4xx.c system_stm32f4xx.h
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../System/delay/: delay.c delay.h
    ../System/sys/: sys.c sys.h
  group Hw_Serial
    ../Hardware/Serial/: uart4.c uart4.h uart5.c uart5.h usart1.c usart1.h usart2.c usart2.h usart3.c usart3.h
  group Hw_Storage
    ../Hardware/Storage/: 24cxx.c 24cxx.h eeprom.c eeprom.h iic.c iic.h
  group Hw_Time
    ../Hardware/Time/: ds1302.c ds1302.h rtc.c rtc.h rtc_util.c rtc_util.h
  group Hw_Board
    ../Hardware/Board/: bsp_hc595.c ext_io.c floor_ctrl.c led.c malloc.c rly.c timer.c wdg.c wdg.h timer.h rly.h malloc.h led.h floor_ctrl.h ext_io.h bsp_hc595.h
  group Hw_Modem
    ../Hardware/Modem/: 4G.c 4G.h
  group Middlewares
    ../Middlewares/: cJSON.c cJSON.h sha1.c sha1.h
  group App_Pass
    ../App/Pass/: cmd.c cmd.h data_handler.c data_handler.h qr_comm.c qr_comm.h pass_crypto.c pass_crypto.h pass_password.c pass_password.h pass_permission.c pass_permission.h pass_setting.c pass_setting.h pass_csv.c pass_csv.h
  group App_Cloud
    ../App/Cloud/: g4g_comm.c Live_data.c Live_data.h Live_data_r.c Live_data_r.h uart3_at_sequence.c uart3_at_sequence.h
  group App_Store
    ../App/Store/: blackList.c blackList.h
  group App_Link
    ../App/Link/: pc_comm.c rs485_comm.c app_comm.h
  group User
    ./: app_run.c app_run.h board_init.c board_init.h main.c main.h stm32f4xx_it.c stm32f4xx_it.h
